DESCRIPTION = "Build stm32f446re image"
LICENSE = "MIT"

SRC_URI=file://
