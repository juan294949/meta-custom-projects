# Keil uVision project stm32f446re_project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f446re_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\header\init-stm32f446RE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group dma
    ../../source/dma/: dma.c
  group initialization_files
    ../../source/init-stm32f446re/: system_stm32f4xx.c startup_stm32f446xx.s
  group Tests
    ./: test_dma.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0
